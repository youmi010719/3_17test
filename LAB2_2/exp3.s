	AREA  INIT, CODE, READONLY
	ENTRY	
	B	RESET_HANDIER
UNDEFINED_HANDIER
	B	UNDEFINED_HANDIER
	B	SWI_HANDIER
PREFETCH_HANDIER
	B	PREFETCH_HANDIER
ABORT_HANDIER	
	B	ABORT_HANDIER
	NOP	
IRQ_HANDIER	
	B	IRQ_HANDIER
FIQ_HANDIER	
	B	FIQ_HANDIER
SWI_HANDIER	
	MOV	PC, LR
RESET_HANDIER	
	MOV	R0, #0x000001F0
	LDR	R1, =0xF0000000
	STR 	R0, [R1]
	MRS	R0, CPSR
	MOV   R13, #1
	MOV	R14, #2
	ADD PC,PC,#4 
	
	MRS	R0, CPSR
	BIC	R0, R0, #0x1F
	ORR	R0, R0, #0x10
	MSR	CPSR_c, R0
	MOV	R13, #3
	MOV	R14, #4

STOP
	B	STOP
       END
